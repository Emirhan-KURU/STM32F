<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MPU6050 and BMP280.ewp</path>
  </project>
  <batchBuild />
</workspace>
